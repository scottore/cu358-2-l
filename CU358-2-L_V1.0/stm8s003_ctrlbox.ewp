# IAR project stm8s003_ctrlbox.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003; EEMEM_USE_SHADOW; NO_SMART_SYNC
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; STM8S_StdPeriph_Driver\inc; nrf24l01; UserApp; nrf24l01\nrf24l01_port; relays
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8s003_ctrlbox.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  ICCSTM8.CCDefines: NDEBUG; STM8S103; EEMEM_USE_SHADOW; NO_SMART_SYNC
  ILINK.IlinkOutputFile: stm8s003_ctrlbox.out
configuration stm8s003_CU358-2-L (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S003; EEMEM_USE_SHADOW; NO_SMART_SYNC
configuration stm8s103_CU358-2-L (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S103K3 STM8S103K3
  ICCSTM8.CCDefines: NDEBUG; STM8S103; EEMEM_USE_SHADOW; NO_SMART_SYNC
  ILINK.IlinkOutputFile: stm8s003_ctrlbox.out
  group (top)
    ./: analog.c analog.h eeprom.c eeprom.h hal_delay.c hal_delay.h main.c misc.c misc.h steuerung.c steuerung.h stm8s_conf.h stm8s_it.c stm8s_it.h sync_communication.c sync_communication.h
  group nrf24l01
    nrf24l01/: nrf24l01.c nrf24l01.h rf-protocol.c rf-protocol.h
  group nrf24l01/nrf24l01_port
    nrf24l01/nrf24l01_port/: nrf24l01_port.c nrf24l01_port.h
  group relays
    relays/: position.c position.h relais.c relais.h
